LED_FILE_asus-tinker-board = "/sys/class/leds/led1-led/brightness"
LED_FILE_asus-tinker-board-s = "/sys/class/leds/led1-led/brightness"
