# disable UPX compression for os-config binary
FILES_COMPRESS = ""